# Repository fumimaker/Ultra96-V2_MIPI_Board

File README.md:

# Ultra96-V2_MIPI_Board
This is a project for a camera board & Pmod expansion board for FPGA board Ultra96-V2.

## Background

Ultra96-V2 is a useful board with MPSoC. However, unlike Zybo, it does not have Pmod and so on and lacks expandability. For my own use, I wanted to connect a MIPI CSI-2 like the Raspi camera, but unfortunately, no IO is available. This time, I will design a board that produces CSI-2 and extra IO.

Please note that this board was developed with reference to [Ryuzi's ultra96_multi_io](https://github.com/ryuz/ultra96v2_multi_io). We thank him here.

## Goal

Ultra96 has differential signal system and other GPIOs from HS Header and LS Header respectively. MIPI seems to come from HS.

We aim to design a board with the following performance.

- CSI-2 4Lane
- CSI-2 2Lane
- Power button and reset button must be out
- PL system LED 4ch
- PL system button 2ch
- PS LED 2ch
- PS button 2ch
- MIO SPI 2ch
- To externalize the rest as Pmod.

As a back-up goal, I am going to use [LCSC](https://www.lcsc.com/). LCSC is a Chinese version of Digikey, with cheap parts, and [JLCPCB](https://jlcpcb.com/), a board manufacturer I often use, is also compatible with LCSC. JLCPCB] (), a board manufacturer I often use, is also supported. I have never used it for some reason, so I will use it as the basis for parts selection this time.

I have written a separate article about this, so please take a look at it.

[https://fumimaker.net/entry/2023/03/03/211528]

## Design

Design using [Eagle](https://www.autodesk.co.jp/products/eagle/overview). I really wanted to learn Kicad, but I found myself starting to build with Eagle out of habit. Next time I will **absolutely** do it with [Kicad](https://www.kicad.org/). (I don't think Eagle is easy to use, so if you are going to do it now, Kicad is the way to go if you have no reason to do it.)

### Power Supply

The power supply is 5V and 1.8V from LS. 3.3V is not available, so we will make it with an appropriate LDO. You should [probably use ADP3338 or something like that](http://nemuisan.blog.bai.ne.jp/?eid=220875), but it is super expensive, so I'll use [any 3 letters] 1117 this time. I really prefer ADP3338 or LT1117, which has higher transient response performance. (For the second time) It's less noisy. It doesn't break. It's good. Expensive, though.

[http://nemuisan.blog.bai.ne.jp/?eid=220875]

<blockquote class="twitter-tweet"><p lang="ja" dir="ltr">[any 3 letters]1117 is too much</p>- fumi (@fumi_maker) <a href="[https://twitter. com/fumi_maker/status/1625060053668745218?ref_src=twsrc^tfw](https://twitter.com/fumi_maker/status/1625060053668745218?ref_src= twsrc%5Etfw)">February 13, 2023</a></blockquote> <script async src="[https://platform.twitter.com/widgets.js](https://platform.twitter. com/widgets.js)" charset="utf-8"></script>

### LS Header

The PL pin coming out of the LS header is Bank26 and is 1.8V. On the other hand, Raspi cameras and other devices communicate with 3.3V GPIOs via I2C. Therefore, it is necessary to convert the level from 1.8V to 3.3V. Also, when using Pmod, 3.3V is easier to handle than 1.8V, so it is converted to 3.3V.
https://www.avnet.com/wps/wcm/connect/onesite/b85b9556-0b2a-42b3-ad6a-8dcf3eac1ff9/Ultra96-V2-HW-User-Guide-v1_3.pdf?MOD=AJPERES&%20CACHEID=ROOTWORKSPACE.Z18_NA5A1I41L0ICD0ABNDMDDG0000-b85b9556-0b2a-42b3-ad6a-8dcf3eac1ff9-nDNP5R3

### HS Header

The high speed signal coming out of the HS header is 1.2V for Bank65. If you want to use this, for example if you want to use DSI as a normal IO, this also needs to be level converted. However, the HS and LS headers of the Ultra96 do not output 1.2V. So, if you want to do it, you will need to make and convert 1.2V by yourself.

The FET for LED drive is selected to be able to switch even at 1.2V.

### Level conversion IC

Texas Instruments [TXS0108EPWR](https://www.lcsc.com/product-detail/_Texas-Instruments-_C17206.html) is selected as a level conversion IC. 1.2V is supported, It supports open-drain and push-pull. I chose this one because it is also used for I2C conversion. I have all of them in this package.

I really wanted to use a smaller package, but the price was about 6 times higher, so I compromised with a larger one.

### HS connector

I use [this](https://jlcpcb.com/partdetail/STWXE-BA41_60CT_1NHB/C508686). I don't know what this one is called, but is it a mezzanine connector? This connector is probably interchangeable, but from the datasheet it looks fine, so I'll use this one. Note that I misread the datasheet for the LS pin headers and got the height wrong (conclusion). If you design like I did, use BA41-60CT-1-NHB. I used BA41-60BT-1-NHB and was 2mm short in height.

[BA41-60CT-1-NHB | STWXE | Mezzanine Connectors (Board to Board) | JLCPCB](https://jlcpcb.com/partdetail/STWXE-BA41_60CT_1NHB/C508686)

### LS Connectors

This is a surface-mount type L-shaped double-row 2mm pin header. It is quite a strange one, and I could not find it at all when I looked for it. I managed to find it at LCSC and use [this](https://www.lcsc.com/product-detail/_XKB-Connectivity-_C917615.html).

### LED related

Some LEDs are driven by 1.2V, so I selected FET onsemi [NTZD3154NT1G](https://www.lcsc.com/product-detail/_onsemi-_C145189.html) which can be driven by 1.2V.

### SW related

It is an ordinary PSW. 200 pieces or so were very cheap at LCSC, so I bought them. It seems to be a proper one from Alps Electric, so it is quite reasonable. (I've used it and it looks like a proper one...)

Also, a DIPSW can be attached, but I forgot to buy it, so it is not mounted.

 Note: The DSI pin is assumed to have an internal pull-up.

# Development

Eagle's feature is that it is built into Fusion, so it can handle 3D models seamlessly. (In addition, I haven't been able to use it properly because I haven't properly registered 3D data in the library.)

Here it is.

## Schematic.

[https://github.com/fumimaker/Ultra96-V2_MIPI_Board](https://github.com/fumimaker/Ultra96-V2_MIPI_Board)

Schematics and designs are available [here](https://github.com/fumimaker/Ultra96-V2_MIPI_Board).

There are two MIPI CSI-2s, CSI0 is 4 Lanes and CSI1 is 2 Lanes. If you want to use a common Raspi Camera, you will use CSI1, and CSI0 was made in case you want to use a 4Lane camera in the future to make me tueeeeeeeeee. This is important because everyone in the world has gone to the Raspi camera standard and there is nothing out there with 4Lane's 22 pin 0.5mm pitch connector. I added the 4Lane connector because I thought it would be necessary in the future if I wanted higher resolution camera images.

I noticed later that the level conversion IC (U3) is slightly out of alignment, which is weird. I will fix it next time. Well, Ultra96 is no longer available, so I'm not sure if there will be a next time...

## BOM

BOM. (Pretty messy, sorry.)

https://github.com/fumimaker/Ultra96-V2_MIPI_Board/blob/main/Ultra96-V2_MIPI_CSI-2_Board_BOM.csv

https://docs.google.com/spreadsheets/d/e/2PACX-1vRyfV2nkdrRBBEGrKsxRo6SP4x0MH9KUVkbMfD3b8DZblvdecDmEF19Au3DwG-mPY6oq2ViDohp0APl/pubhtml?gid=1667383814&single=true

# Ordering

I am ordering a board from [JLCPCB](https://jlcpcb.com/). They have always been good to me and I recommend them for good quality. I'd like to try PCBA one of these days.

https://jlcpcb.com/

This setup is 1.6mm thick, EING (gold flats) finish, and black.

# Received.

The board arrived. The usual blue box.

I have a lot of these at home so I wrote my name on them to make it easier to find them.

They are very clean like this. I knew the black matte and EING would be...awesome! Super cool and highly recommended.

The dachs is still sitting on it and it is good.

## Aside.

By the way, I wonder if they make Ultra96 anymore.... It was nice and small.... The successor looks like KV260, but I think it's a bit big. I would like MPSoC Zybo if possible.... I wonder if someone could make one for me (other power).

Next, I will make an expansion board for the KV260 (or rather a carrier board for the SOM K26). (I hope) Some people want to use it that way.

# Next time

I'll try to implement it and make it actually work.

## EAGLE design ultra96_mipi.brd

Parts:
C1, C2, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: 0.1; C0603
C3, C4: 10u; C0603
CSI0: FH34SRJ-22S-0.5SH(50); HRS_FH34SRJ-22S-0.5SH(50)
CSI1: 1-84952-5; TE_1-84952-5
J1: 5177984-2; 51779842
J2: 57202-G52-20LFCONN40_52-20LF_AMP; CONN40_52-20LF_AMP
JP1, JP2, JP3: JUMPER-SMT_3_1-NC_PASTE_SILK; SMT-JUMPER_3_1-NC_PASTE_SILK
JP4: PINHD-2X8; 2X08
LED1, LED2, LED3, LED4, LED5, LED6: LED1608
PMOD1, PMOD2: PINHD-2X6/90; 2X06/90
POW: LED1608
PSW1, PSW2, PSW3, PSW4: SKRPACE010
PWR: SKRPACE010
Q1, Q2, Q3: NTZD3154NT1G; SOTFL50P160X60-6N
R1, R3, R5, R7, R10, R13, R20, R23: 10k; R0603
R2, R6, R9, R12, R16, R19, R22: 1k; R0603
R4, R8, R11, R14, R21, R24: 100; R0603
R15, R25: EXB-28V470JX 2.2k; EXB-28V470JX
RST: SKRPACE010
S1: 219-04; CTS-219-04
U1, U2, U3, U4, U5: TXS0108EPWR-TSSOP20; TSSOP20-0.65-6.5X4.4MM
U6: AMS1117-3.3; SOT229P700X180-4N

Connections:
1.8V: C2.1, C5.2, C7.2, C9.2, C15.2, C17.2, J2.35, JP4.2, R1.1, R5.1, U1.2 (VCCA), U1.10 (OE), U2.2 (VCCA), U2.10 (OE), U3.2 (VCCA), U3.10 (OE), U4.2 (VCCA), U4.10 (OE), U5.2 (VCCA), U5.10 (OE)
+3V3: C4.1, C10.2, C11.2, C12.2, CSI0.22, CSI1.15, JP1.3, JP2.3, JP3.3, JP4.1, R25.5, R25.6, R25.7, R25.8, U3.19 (VCCB), U6.2 (VOUT), U6.4 (VOUT)
+5V: C1.1, C3.1, J2.37, JP1.1, JP2.1, JP3.1, R2.2, R6.2, R9.2, R12.2, R16.2, R19.2, R22.2, U6.3 (VIN)
CAM0_GPIO: CSI0.17, U3.20 (B1)
CAM0_I2C_SCL: CSI0.20, R25.1, U3.17 (B3)
CAM0_I2C_SDA: CSI0.21, R25.2, U3.16 (B4)
CAM1_GPIO: CSI1.11, U3.18 (B2)
CAM1_I2C_SCL: CSI1.13, R25.3, U3.15 (B5)
CAM1_I2C_SDA: CSI1.14, R25.4, U3.14 (B6)
CSI0_CLK_N: CSI0.8, J1.4
CSI0_CLK_P: CSI0.9, J1.2
CSI0_D0_N: CSI0.2, J1.10
CSI0_D0_P: CSI0.3, J1.8
CSI0_D1_N: CSI0.5, J1.16
CSI0_D1_P: CSI0.6, J1.14
CSI0_D2_N: CSI0.11, J1.22
CSI0_D2_P: CSI0.12, J1.20
CSI0_D3_N: CSI0.14, J1.28
CSI0_D3_P: CSI0.15, J1.26
CSI0_MCLK: J1.15
CSI1_CLK_N: CSI1.8, J1.56
CSI1_CLK_P: CSI1.9, J1.54
CSI1_D0_N: CSI1.2, J1.44
CSI1_D0_P: CSI1.3, J1.42
CSI1_D1_N: CSI1.5, J1.50
CSI1_D1_P: CSI1.6, J1.48
CSI1_MCLK: J1.17
DSI_CLK_N: J1.23, PSW1.1 (0), PSW1.2 (0)
DSI_CLK_P: J1.21, PSW2.1 (0), PSW2.2 (0)
DSI_D0_N: J1.29, R4.1
DSI_D0_P: J1.27, R8.1
DSI_D1_N: J1.35, R11.1
DSI_D1_P: J1.33, R14.1
DSI_D2_N: J1.41, S1.1
DSI_D2_P: J1.39, S1.2
DSI_D3_N: J1.47, S1.3
DSI_D3_P: J1.45, S1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, CSI0.1, CSI0.4, CSI0.7, CSI0.10, CSI0.13, CSI0.16, CSI0.19, CSI0.S1 (SHIELD), CSI0.S2 (SHIELD), CSI1.1, CSI1.4, CSI1.7, CSI1.10, CSI1.S1 (SHIELD), CSI1.S2 (SHIELD), J1.6, J1.12, J1.13, J1.18, J1.19, J1.24, J1.25, J1.30, J1.31, J1.37, J1.40, J1.43, J1.46, J1.49, J1.52, J1.55, J1.58, J2.1, J2.2, J2.39, J2.40, JP4.15, JP4.16, PMOD1.9, PMOD1.10, PMOD2.9, PMOD2.10, POW.K, PSW1.3 (1), PSW1.4 (1), PSW2.3 (1), PSW2.4 (1), PSW3.3 (1), PSW3.4 (1), PSW4.3 (1), PSW4.4 (1), PWR.3 (1), PWR.4 (1), Q1.1 (S1), Q1.4 (S1), Q2.1 (S1), Q2.4 (S1), Q3.1 (S1), Q3.4 (S1), R3.1, R7.1, R10.1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
HS_I2C2_SCL: J1.32, U3.4 (A3)
HS_I2C2_SDA: J1.34, U3.5 (A4)
HS_I2C3_SCL: J1.36, U3.6 (A5)
HS_I2C3_SDA: J1.38, U3.7 (A6)
LS_GPIO0: J2.3, U1.1 (A1)
LS_GPIO1: J2.5, U1.3 (A2)
LS_GPIO2: J2.7, U1.4 (A3)
LS_GPIO3: J2.9, U1.5 (A4)
LS_GPIO4: J2.11, U1.6 (A5)
LS_GPIO5: J2.13, U1.7 (A6)
LS_GPIO6: J2.29, U1.8 (A7)
LS_GPIO7: J2.31, U1.9 (A8)
LS_GPIO8: J2.33, U3.1 (A1)
LS_GPIO9: J2.16, U3.3 (A2)
LS_GPIO10: J2.18, U2.1 (A1)
LS_GPIO11: J2.20, U2.3 (A2)
LS_GPIO12: J2.22, U2.4 (A3)
LS_GPIO13: J2.30, U2.5 (A4)
LS_GPIO14: J2.32, U2.6 (A5)
LS_GPIO15: J2.34, U2.7 (A6)
LS_I2C0_SCL: J2.15, U5.1 (A1)
LS_I2C0_SDA: J2.17, U5.3 (A2)
LS_I2C1_SCL: J2.19, U5.4 (A3)
LS_I2C1_SDA: J2.21, U5.5 (A4)
LS_MIO36_GPIO1_0: J2.23, R21.1
LS_MIO37_GPIO1_1: J2.24, R24.1
LS_MIO38_SPI0_SCLK: J2.8, U4.1 (A1)
LS_MIO39_GPIO1_2: J2.25, PSW3.1 (0), PSW3.2 (0), R1.2
LS_MIO40_GPIO1_3: J2.26, PSW4.1 (0), PSW4.2 (0), R5.2
LS_MIO41_SPI0_CS: J2.12, U4.4 (A3)
LS_MIO42_SPI0_MISO: J2.10, U4.3 (A2)
LS_MIO43_SPI0_MOSI: J2.14, U4.5 (A4)
LS_MIO44_GPIO1_4: J2.27, U2.8 (A7)
LS_MIO45_GPIO1_5: J2.28, U2.9 (A8)
MIO6_SPI1_SCLK: J1.9, U4.6 (A5)
MIO9_SPI1_CS: J1.7, U4.8 (A7)
MIO10_SPI1_MISO: J1.11, U4.7 (A6)
MIO11_SPI1_MOSI: J1.1, U4.9 (A8)
unnamed: LED1.A, R2.1
unnamed: LED1.K, Q1.6 (D1)
unnamed: Q1.2 (G1), R3.2, R4.2
unnamed: LED3.A, R9.1
unnamed: LED2.A, R6.1
unnamed: LED3.K, Q2.6 (D1)
unnamed: POW.A, R16.1
unnamed: LED2.K, Q1.3 (D1)
unnamed: LED4.K, Q2.3 (D1)
unnamed: Q1.5 (G1), R7.2, R8.2
unnamed: Q2.2 (G1), R10.2, R11.2
unnamed: LED5.A, R19.1
unnamed: LED4.A, R12.1
unnamed: LED5.K, Q3.6 (D1)
unnamed: Q3.2 (G1), R20.2, R21.2
unnamed: LED6.A, R22.1
unnamed: LED6.K, Q3.3 (D1)
unnamed: Q3.5 (G1), R23.2, R24.2
unnamed: Q2.5 (G1), R13.2, R14.2
PH1_1: JP4.3, U4.20 (B1)
PH1_2: JP4.4, U4.18 (B2)
PH1_3: JP4.5, U4.17 (B3)
PH1_4: JP4.6, U4.16 (B4)
PH1_5: JP4.7, U4.15 (B5)
PH1_6: JP4.8, U4.14 (B6)
PH1_7: JP4.9, U4.13 (B7)
PH1_8: JP4.10, U4.12 (B8)
PH1_9: JP4.11, R15.1, U5.20 (B1)
PH1_10: JP4.12, R15.2, U5.18 (B2)
PH1_11: JP4.13, R15.3, U5.17 (B3)
PH1_12: JP4.14, R15.4, U5.16 (B4)
PINHD1_VDD: C16.2, C18.2, JP3.2, R15.5, R15.6, R15.7, R15.8, U4.19 (VCCB), U5.19 (VCCB)
PMOD1_1: PMOD1.1, U1.20 (B1)
PMOD1_2: PMOD1.3, U1.18 (B2)
PMOD1_3: PMOD1.5, U1.17 (B3)
PMOD1_4: PMOD1.7, U1.16 (B4)
PMOD1_5: PMOD1.2, U1.15 (B5)
PMOD1_6: PMOD1.4, U1.14 (B6)
PMOD1_7: PMOD1.6, U1.13 (B7)
PMOD1_8: PMOD1.8, U1.12 (B8)
PMOD1_VDD: C8.2, C13.2, JP1.2, PMOD1.11, PMOD1.12, U1.19 (VCCB)
PMOD2_1: PMOD2.1, U2.20 (B1)
PMOD2_2: PMOD2.3, U2.18 (B2)
PMOD2_3: PMOD2.5, U2.17 (B3)
PMOD2_4: PMOD2.7, U2.16 (B4)
PMOD2_5: PMOD2.2, U2.15 (B5)
PMOD2_6: PMOD2.4, U2.14 (B6)
PMOD2_7: PMOD2.6, U2.13 (B7)
PMOD2_8: PMOD2.8, U2.12 (B8)
PMOD2_VDD: C6.2, C14.2, JP2.2, PMOD2.11, PMOD2.12, U2.19 (VCCB)
PWR_BTN: J2.4, PWR.1 (0), PWR.2 (0)
RST_BTN: J2.6, RST.1 (0), RST.2 (0)

Notes on the sheet:
60PIN HS EXP HDR
40P LS EXP HDR
Pmod power selector Nomally +3V3
内蔵プルアップ

Board: 2 copper layers, 85.0 x 54.0 mm, 74 parts (2 on the bottom side), 126 nets.

File Ultra96-V2_MIPI_CSI-2_Board_BOM.csv:

Part,Value,Device,Package,Description,ARROW_PART_NUMBER,ARROW_PRICE-STOCK,AVAILABILITY,CATEGORY,COMMENT,COPYRIGHT,CREATED_BY,DESCRIPTION,DIGI-KEY_PART_NUMBER_1,DIGIKEY_PARTNO,EU_ROHS_COMPLIANCE,HEIGHT,MANUFACTURER,MANUFACTURER_NAME,MANUFACTURER_PART_NUMBER,MF,MFR_NAME,MOUSER_PART_NUMBER,MOUSER_PRICE-STOCK,MOUSER_TESTING_PART_NUMBER,MOUSER_TESTING_PRICE-STOCK,MP,MPN,OC_FARNELL,OC_NEWARK,OPERATING_TEMP,PACKAGE,PART_STATUS,POPULARITY,PRICE,PURCHASE-URL,ROHS_COMPLIANT,SERIES,SPICEPREFIX,SUB-CATEGORY,THERMALLOSS,TYPE,VALUE
C1,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C2,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C3,10u,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C4,10u,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C5,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C6,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C7,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C8,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C9,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C10,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C11,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C12,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C13,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C14,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C15,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C16,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C17,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
C18,0.1,C-EUC0603,C0603,CAPACITOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
CSI0,FH34SRJ-22S-0.5SH(50),FH34SRJ-22S-0.5SH(50),HRS_FH34SRJ-22S-0.5SH(50),Check availability,,,In Stock,,,,, 22 Position FFC,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
CSI1,1-84952-5,1-84952-5,TE_1-84952-5,,,,,,1-84952-5,,,,,,Compliant,,,,,,,,,,,,,,,,,,,,,,,,,,,
J1,5177984-2,5177984-2,51779842,60 way 0.8mm pitch SMT header,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
J2,57202-G52-20LFCONN40_52-20LF_AMP,57202-G52-20LFCONN40_52-20LF_AMP,CONN40_52-20LF_AMP,,,,,,,Copyright (C) 2023 Ultra Librarian. All rights reserved.,,,609-2632-ND,,,,,,57202-G52-20LF,,Amphenol ICC,,,,,,,,,,,,,,,,,,,,,
JP1,JUMPER-SMT_3_1-NC_PASTE_SILK,JUMPER-SMT_3_1-NC_PASTE_SILK,SMT-JUMPER_3_1-NC_PASTE_SILK,Normally closed solder jumper (1 of 2 connections),,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
JP2,JUMPER-SMT_3_1-NC_PASTE_SILK,JUMPER-SMT_3_1-NC_PASTE_SILK,SMT-JUMPER_3_1-NC_PASTE_SILK,Normally closed solder jumper (1 of 2 connections),,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
JP3,JUMPER-SMT_3_1-NC_PASTE_SILK,JUMPER-SMT_3_1-NC_PASTE_SILK,SMT-JUMPER_3_1-NC_PASTE_SILK,Normally closed solder jumper (1 of 2 connections),,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
JP4,PINHD-2X8,PINHD-2X8,2X08,PIN HEADER,,,,CONNECTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,PIN-HEADER,,,
LED1,LED1608,LED1608,LED1608,Generic LEDs,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
LED2,LED1608,LED1608,LED1608,Generic LEDs,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
LED3,LED1608,LED1608,LED1608,Generic LEDs,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
LED4,LED1608,LED1608,LED1608,Generic LEDs,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
LED5,LED1608,LED1608,LED1608,Generic LEDs,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
LED6,LED1608,LED1608,LED1608,Generic LEDs,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
PMOD1,PINHD-2X6/90,PINHD-2X6/90,2X06/90,PIN HEADER,,,,CONNECTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,PIN-HEADER,,,
PMOD2,PINHD-2X6/90,PINHD-2X6/90,2X06/90,PIN HEADER,,,,CONNECTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,PIN-HEADER,,,
POW,LED1608,LED1608,LED1608,Generic LEDs,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
PSW1,,SKRPACE010,SKRPACE010,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
PSW2,,SKRPACE010,SKRPACE010,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
PSW3,,SKRPACE010,SKRPACE010,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
PSW4,,SKRPACE010,SKRPACE010,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
PWR,,SKRPACE010,SKRPACE010,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
Q1,NTZD3154NT1G,NTZD3154NT1G,SOTFL50P160X60-6N,Dual N-channel MOSFET Transistor,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
Q2,NTZD3154NT1G,NTZD3154NT1G,SOTFL50P160X60-6N,Dual N-channel MOSFET Transistor,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
Q3,NTZD3154NT1G,NTZD3154NT1G,SOTFL50P160X60-6N,Dual N-channel MOSFET Transistor,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R1,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R2,1k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R3,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R4,100,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R5,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R6,1k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R7,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R8,100,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R9,1k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R10,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R11,100,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R12,1k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R13,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R14,100,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R15,EXB-28V470JX 2.2k,EXB-28V470JX,EXB-28V470JX,RES ARRAY 4 RES 47 OHM 0804,,,,,,,PCBLayout.com,,,Y7470TR-ND,,,Panasonic Electronic Components,,,,,,,,,,EXB-28V470JX,,,,804,,,,,,,,,,,
R16,1k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R19,1k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R20,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R21,100,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R22,1k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R23,10k,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R24,100,R-EU_R0603,R0603,RESISTOR,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
R25,EXB-28V470JX 2.2k,EXB-28V470JX,EXB-28V470JX,RES ARRAY 4 RES 47 OHM 0804,,,,,,,PCBLayout.com,,,Y7470TR-ND,,,Panasonic Electronic Components,,,,,,,,,,EXB-28V470JX,,,,804,,,,,,,,,,,
RST,,SKRPACE010,SKRPACE010,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,,
S1,219-04,219-04,CTS-219-04,Surface Mount DIP Switch Series 219 SMT,,,,,,,,,,,,,,,,,,,,,,,,unknown,unknown,,,,,,,,,,,,,
U1,TXS0108EPWR-TSSOP20,LOGIC-TXS0108EPWR(TSSOP20),TSSOP20-0.65-6.5X4.4MM,310050026,,,,,,,,,,,,,,,,,,,,,,,TXS0108EPWR,,,,,,,,,,,,,,,TXS0108EPWR-TSSOP20
U2,TXS0108EPWR-TSSOP20,LOGIC-TXS0108EPWR(TSSOP20),TSSOP20-0.65-6.5X4.4MM,310050026,,,,,,,,,,,,,,,,,,,,,,,TXS0108EPWR,,,,,,,,,,,,,,,TXS0108EPWR-TSSOP20
U3,TXS0108EPWR-TSSOP20,LOGIC-TXS0108EPWR(TSSOP20),TSSOP20-0.65-6.5X4.4MM,310050026,,,,,,,,,,,,,,,,,,,,,,,TXS0108EPWR,,,,,,,,,,,,,,,TXS0108EPWR-TSSOP20
U4,TXS0108EPWR-TSSOP20,LOGIC-TXS0108EPWR(TSSOP20),TSSOP20-0.65-6.5X4.4MM,310050026,,,,,,,,,,,,,,,,,,,,,,,TXS0108EPWR,,,,,,,,,,,,,,,TXS0108EPWR-TSSOP20
U5,TXS0108EPWR-TSSOP20,LOGIC-TXS0108EPWR(TSSOP20),TSSOP20-0.65-6.5X4.4MM,310050026,,,,,,,,,,,,,,,,,,,,,,,TXS0108EPWR,,,,,,,,,,,,,,,TXS0108EPWR-TSSOP20
U6,AMS1117-3.3,AMS1117-3.3,SOT229P700X180-4N,Check availability,,,In Stock,,,,, Sot223/Pkg 1-Amp 3.3-Volt Low Drop Out Voltage Regulatator ,,,,,,,,Advanced Monolithic Systems,,,,,,AMS1117-3.3,,,,,SOT-223 Seeed Technology,,,None,,,,,,,,

## Commit log

2023-04-14 add src

Notices in the files:
parts and their libraries:
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
COPYRIGHT: Copyright (C) 2023 Ultra Librarian. All rights reserved.
